FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += " \
	file://0001-change-can-clock-to-40-mhz.patch \	
	"
